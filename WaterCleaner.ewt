<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>hd44780_driver</name>
    <file>
      <name>$PROJ_DIR$\hd44780_driver\hd44780.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hd44780_driver\hd44780.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hd44780_driver\hd44780_hal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hd44780_driver\hd44780_hal.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\hd44780_driver\lcd_cfg.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\Automation.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Automation.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Buttons.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Buttons.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\DisplayDriver.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\DisplayDriver.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\eeprom.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\eeprom.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\gpio.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\gpio.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\HardwareControl.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\HardwareControl.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\MenuControl.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\MenuControl.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\pin_input.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\pin_input.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\pin_output.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\pin_output.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\StateMachine.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\StateMachine.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\UptimeService.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\UptimeService.h</name>
  </file>
</project>


