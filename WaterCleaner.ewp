# IAR project WaterCleaner.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S005K6 STM8S005K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: C:\iar_projects\WaterCleaner; C:\iar_projects\WaterCleaner\hd44780_driver
  ICCSTM8.CCDefines: STM8S005
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: WaterCleaner.srec
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  ICCSTM8.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: WaterCleaner.out
  group (top)
    ./: Automation.c Automation.h Buttons.c Buttons.h DisplayDriver.c DisplayDriver.h eeprom.c eeprom.h gpio.c gpio.h HardwareControl.c HardwareControl.h main.c MenuControl.c MenuControl.h pin_input.c pin_input.h pin_output.c pin_output.h StateMachine.c StateMachine.h UptimeService.c UptimeService.h
  group hd44780_driver
    hd44780_driver/: hd44780.c hd44780.h hd44780_hal.c hd44780_hal.h lcd_cfg.h
